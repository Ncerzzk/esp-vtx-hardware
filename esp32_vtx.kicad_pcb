# Repository Ncerzzk/esp-vtx-hardware

File README.md:

## ESP VTX
基于WIFI-Broadcast原理的ESP32图传。

## 使用说明
### 天空端

### 地面站
- 需要一张能运行monitor模式的2.4G网卡，典型如ar9271 和 Pi(树莓派或各种国产派）
- 将ar9271插入地面站，通过ifconfig 可以看到此时多了一个网络接口
- 使用`sudo tcpdump --monitor-mode -i wlan1` 来测试当前系统和网卡是否支持monitor 模式，如果没有报错，且能正常dump数据，那么即为正常。注意将wlan1 换成你自己的接口名
- 编译地面站
    - 编辑gs/src/main.cpp,将rx_descriptor.interfaces 和 tx_descriptor.interface 更改为你自己的接口名
    - 安装依赖`sudo apt install libdrm-dev libgbm-dev libgles2-mesa-dev libpcap-dev libturbojpeg0-dev libts-dev libsdl2-dev libfreetype6-dev`
    - `cd gs; make`
    - 运行`sudo DISPLAY=:0 ./gs` , 注意DISPLAY有可能是:0.0

## KiCad design esp32_vtx.kicad_pcb

Parts:
C1, C5, C7, C8, C12, C13: 10uF; C_0603_1608Metric
C2: 15pF; C_0603_1608Metric
C3: 100uF; CP_EIA-3216-18_Kemet-A
C4, C6, C17, C18, C19: 10u; C_0603_1608Metric
C9, C11: 1u; C_0603_1608Metric
C10, C15: 0.1u; C_0603_1608Metric
C14, C16: 0.1uF; C_0603_1608Metric
D1: LED; LED_0603_1608Metric
H1, H2, H3, H4: MountingHole; MountingHole_2.2mm_M2
J1: Conn_01x24_MountingPin; Hirose_FH12-24S-0.5SH_1x24-1MP_P0.50mm_Horizontal_larger
J2: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
R1, R11, R13, R15, R16, R17, R18: 10K; R_0603_1608Metric
R9, R14: 4K7; R_0603_1608Metric
R12: 1K; R_0603_1608Metric
RF1: BWIPX-1-001E; IPEX-SMD_BWIPX-1-001E
SW1, SW2: SW_SPST; SW_SPST_B3U-1000P
U1: AMS1117-3.3; SOT-223-3_TabPin2
U2: IS25WP032; SOIC-8_3.9x4.9mm_P1.27mm
U3: ESP32-PICO-D4; QFN-48-1EP_7x7mm_P0.5mm_EP5.3x5.3mm
U4: MKDV4GCL-AB; LGA-8_L8.0-W6.0-BL_MKDV4GIL-AS
U5: XC6206-2.8V; SOT-23
U6: XC6206-1.2V; SOT-23

Connections:
+1V2: C12.1, C14.1, J1.15, U6.2 (VO)
+2V8: C13.1, C16.1, J1.21, U5.2 (VO)
+3V3: C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C10.2, C15.2, C17.1, C18.1, C19.1, J1.14, R1.2, R9.1, R11.2, R13.1, R14.1, R15.1, R16.1, R17.1, R18.1, U1.2 (VO), U2.8 (VCC), U3.1 (VDDA), U3.3 (VDDA3P3), U3.4 (VDDA3P3), U3.19 (VDD3P3_RTC), U3.26 (VDD_SDIO), U3.37 (VDD3P3_CPU), U3.43 (VDDA), U3.46 (VDDA), U4.8 (VDD), U5.3 (VI), U6.3 (VI)
+5V: C1.1, J2.1, U1.3 (VI)
/D2: J1.6, U3.10 (IO34)
/D3: J1.4, U3.7 (SENSOR_CAPN)
/D4: J1.3, U3.5 (SENSOR_VP)
/D5: J1.5, U3.8 (SENSOR_VN)
/D6: J1.7, U3.11 (IO35)
/D7: J1.9, U3.39 (IO22)
/D8: J1.11, U3.38 (IO19)
/D9: J1.13, U3.35 (IO18)
/EN: C11.1, R11.1, U3.9 (EN)
/GPIO0: SW2.1 (A), U3.23 (IO0)
/GPIO2: R13.2, SW1.1 (A), U3.22 (IO2), U4.6 (DAT0)
/HS: J1.16, U3.34 (IO5)
/KEY: U3.6 (SENSOR_CAPP)
/MCLK: J1.12, U3.36 (IO23)
/PCLK: C2.1, J1.8, U3.42 (IO21)
/PSRAM_CE: U2.1 (~CE), U3.29 (SD3/IO10)
/PWDN: J1.17, U3.12 (IO32)
/RESET: C9.1, J1.19, R1.1
/RFOUT: RF1.1 (SIG), U3.2 (LNA_IN)
/RX: J2.3, U3.40 (U0RXD/IO3)
/SCL: J1.20, R14.2, U3.15 (IO26)
/SCLK: U2.6 (SCLK), U3.31 (CLK)
/SDA: J1.22, R9.2, U3.16 (IO27)
/SD_CLK: U3.17 (IO14), U4.3 (CLK)
/SD_CMD: R18.2, U3.21 (IO15), U4.5 (CMD)
/SD_DATA1: R15.2, U3.24 (IO4), U4.7 (DAT1)
/SD_DATA2: R16.2, U3.18 (IO12), U4.1 (DAT2)
/SD_DATA3: R17.2, U3.20 (IO13), U4.2 (DAT3)
/SI: U2.5 (SI/SIO), U3.33 (SD1)
/SIO2: U2.3 (SIO2), U3.32 (SD0)
/SIO3: U2.7 (SIO3), U3.30 (CMD)
/SO: U2.2 (SO/SIO), U3.27 (IO17)
/TX: J2.2, U3.41 (U0TXD/IO1)
/VS: J1.18, U3.14 (IO25)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.1, C11.2, C12.2, C13.2, C14.2, C15.1, C16.2, C17.2, C18.2, C19.2, D1.1 (K), J1.10, J1.23, J1.MP (MountPin), J2.4, RF1.2 (GND), RF1.3 (GND), SW1.2 (B), SW2.2 (B), U1.1 (GND), U2.4 (VSS), U3.49 (GND), U4.4 (GND), U5.1 (GND), U6.1 (GND)
unnamed: D1.2 (A), R12.2
unnamed: R12.1, U3.13 (IO33)

Notes on the sheet:
烧程序时，这个电阻不能焊 或者烧一下efuse

Board: 4 copper layers, 20.1 x 39.6 mm, 45 parts (18 on the bottom side), 40 nets.

## Commit log

2023-02-25 v0.9 ok. use ldo instead of dcdc.
2023-03-02 add cap near pclk, change package of res and cap to 0603
2023-11-12 changes pclk cap value to 22pf instead of 0.1uF
2023-11-19 v1.1 tested.
